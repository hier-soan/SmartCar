# Keil uVision project MyCar.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MyCar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\src
  asm include: .\src
  group 源组 1
    ./: STARTUP.A51
    ./src/: main.c headfile.h motor.c motor.h isr.c isr.h servo.c servo.h AD.c AD.h
